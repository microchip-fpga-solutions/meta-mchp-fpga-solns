PACKAGECONFIG:append:mpfs-video-kit-httpd-all = " apache2"
