HOMEPAGE = "https://github.com/microchip-fpga-solutions/linux4polarfire"
SUMMARY = "Microchip PolarFire FPGA out-of-tree kernel drivers"
DESCRIPTION = "Out-of-tree kernel modules from linux4polarfire. \
Auto-discovers all driver subdirectories containing a Makefile via \
the top-level Makefile and builds them against the target kernel."

LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=a362c03f8df4e23f8a155e1cb2c45b2a"

inherit module

require linux4polarfire-src.inc

SRC_URI += "file://mchp-coretse-softdep.conf"
PV = "1.0.0"

S = "${WORKDIR}/git"

# Top-level Makefile auto-discovers all drivers/ subdirectories.
# New drivers added to the branch are built automatically.
#
# CONFIG_CORE1588_HWTSTAMP is declared "bool" (not tristate) in the coretse
# driver's Kconfig, so its Makefile's "obj-$(CONFIG_CORE1588_HWTSTAMP)" line
# only ever expands to obj-y (never obj-m) when left at its ?=y default.
# For out-of-tree (M=) module builds, kbuild silently drops obj-y entries
# since there is no vmlinux to link them into, so mchp_core1588_ptp.ko was
# never produced. Forcing =m here makes it expand to obj-m, producing a
# proper standalone .ko.
#
# Separately, mchp_coretse.c itself guards its PTP ethtool/ioctl support
# (get_ts_info, SIOCSHWTSTAMP/SIOCGHWTSTAMP) behind "#ifdef
# CONFIG_CORE1588_HWTSTAMP". That macro is normally generated by Kconfig
# into include/generated/autoconf.h for symbols in the kernel's own
# .config - but CONFIG_CORE1588_HWTSTAMP only exists in this out-of-tree
# driver's local Kconfig, which the real kernel never sources, so the
# macro is never defined and that code is silently compiled out (even
# though the Makefile variable above correctly builds mchp_core1588_ptp.ko
# as a separate module and it probes fine, exposing /dev/ptp0). Without
# get_ts_info wired up, "ethtool -T eth1" always reports
# "PTP Hardware Clock: none" even though bp->timer is correctly linked at
# runtime. KCFLAGS defines the macro for the compiler explicitly.
EXTRA_OEMAKE += "KERNEL_SRC=${STAGING_KERNEL_DIR} CONFIG_CORE1588_HWTSTAMP=m KCFLAGS='-DCONFIG_CORE1588_HWTSTAMP=1'"

do_install() {
    install -d ${D}${nonarch_base_libdir}/modules/${KERNEL_VERSION}/extra
    for ko in $(find ${S}/drivers -name "*.ko"); do
        install -m 0644 ${ko} ${D}${nonarch_base_libdir}/modules/${KERNEL_VERSION}/extra/
    done

    # Force mchp_core1588_ptp to load (and finish probing) before
    # mchp_coretse. See comment above EXTRA_OEMAKE and the conf file itself
    # for why this is required and why it cannot be fixed in the driver
    # source.
    install -d ${D}${sysconfdir}/modprobe.d
    install -m 0644 ${WORKDIR}/mchp-coretse-softdep.conf ${D}${sysconfdir}/modprobe.d/mchp-coretse-softdep.conf
}

FILES:${PN} += "${sysconfdir}/modprobe.d/mchp-coretse-softdep.conf"

RPROVIDES:${PN} += "kernel-module-mchp-coretse kernel-module-mchp-core1588-ptp kernel-module-microchip-tsn"
