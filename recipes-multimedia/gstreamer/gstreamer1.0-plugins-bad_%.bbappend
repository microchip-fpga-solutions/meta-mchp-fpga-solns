PACKAGECONFIG:remove:mpfs-video-kit-drm = " directfb"
PACKAGECONFIG:remove:mpfs-video-kit-drm = " vulkan"
PACKAGECONFIG:append:mpfs-video-kit-drm = " kms"

